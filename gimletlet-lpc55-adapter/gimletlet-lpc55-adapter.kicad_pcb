# Repository oxidecomputer/hw-lpc55-carrier

File README.md:

# hw-lpc55-carrier
Daughterboard which plugs into the Gemini Bringup Board (and gimletlet's carrier-carrier) and provides an LPC55 (root of trust microcontroller)

# Bonus Boards

In order to interface with a gimletlet, the LPC55Carrier-Carrier

## KiCad design gimletlet-lpc55-adapter/gimletlet-lpc55-adapter.kicad_pcb

Parts:
C1, C2, C3: 1µF; C_0603_1608Metric; MPN C0603C105K4RAC7867
D1: Green; LED_0603_1608Metric; MPN 150060GS75000
D2: Red; LED_0603_1608Metric; MPN 150060RS75000
D3: Amber; LED_0603_1608Metric; MPN 150060AS75000
H1, H2: M3; MountingHole_3.2mm_M3
H3: GRAPHIC PLACEHOLDER; newt_of_trust
J1: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Horizontal; MPN PEC06DGBN
J2: Conn_ARM_JTAG_SWD_10; PinHeader_2x05_P1.27mm_Vertical_SMD; MPN FTSH-105-01-F-DV-K
J3: Conn_2Rows-51Pins; DF9-51P-1V; MPN DF9-51P-1V(69)
J4: USART; PinHeader_1x06_P2.54mm_Vertical; MPN PR20206VBNN
J5: Conn_01x06; PinSocket_1x06_P2.54mm_Vertical; MPN PPTC061LFBN-RC
J6: SPI; PinSocket_1x06_P2.54mm_Horizontal; MPN PPPC061LGBN-RC
R1, R2, R3, R7: 143Ω; R_0603_1608Metric; MPN RC0603FR-07143RL
R4, R5: 22Ω; R_0603_1608Metric; MPN RT0603FRE0722RL
R6: 10KΩ; R_0603_1608Metric; MPN RC0603FR-0710KP
SW1: SW_SPST; SW_SPST_PTS810; MPN PTS810 SJS 250 SMTR LFS
SW2: SW_SPDT; SW_SPDT_CK-JS102011SAQN; MPN JS102011SAQN
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8: TestPoint; TestPoint_Keystone_5015_Micro-Minature; MPN 5015
TP9, TP10, TP11, TP12, TP13, TP14, TP15: TestPoint; TestPoint_Pad_1.5x1.5mm; MPN 5015

Connections:
+3V3: C1.1, C2.1, C3.1, D1.2 (A), J1.1, J1.2, J2.1 (VTref), J3.44, J3.46, J3.47, J3.48, J3.49, J3.50, J3.51, J5.1, J6.1, R6.2, TP7.1
/FC0_RXD: J3.36, J4.4, TP14.1
/FC0_TXD: J3.40, J4.5, TP15.1
/FC3_CTS_SDAX_SSEL0: J6.6, R7.1
/FC3_RTS_SCLX_SSEL1: J3.28, J5.6, TP9.1
/FC3_RXD_DSA_MOSI: J6.5, R5.1
/FC3_SCK: J6.3, R4.1
/FC3_TXD_SCL_MISO: J3.16, J6.4, TP11.1
/ISP0: J3.3, SW2.2 (B)
/PIO0_4: J3.8, J5.3, TP10.1
/PIO0_22: J3.24, J5.5, TP13.1
/PIO0_25: J3.20, J5.4, TP12.1
/SCT0_OUT2: D2.2 (A), J3.31
/SCT0_OUT3: D3.2 (A), J3.33
/SPI_MISO: J1.7, J3.7, TP3.1
/SPI_MOSI: J1.9, J3.15, TP2.1
/SPI_SCK: J1.5, J3.11, TP4.1
/SWD_CLK: J2.4 (SWDCLK/TCK), J3.39
/SWD_IO: J2.2 (SWDIO/TMS), J3.41
/SWD_TRACESWO: J2.6 (SWO/TDO), J3.37
/~SPI_CS: J1.11, J3.19, R6.1, TP1.1
/~SPI_IRQ: J1.12, J3.23, TP5.1
/~SPI_RESET: J1.10, J3.27, TP6.1
/~SWD_RESET: J2.10 (~RESET), J3.43, SW1.2 (B)
GND: C1.2, C2.2, C3.2, J1.3, J1.4, J2.3 (GND), J2.5 (GND), J2.9 (GNDDetect), J3.1, J3.2, J3.5, J3.6, J3.9, J3.10, J3.13, J3.14, J3.17, J3.18, J3.21, J3.22, J3.25, J3.26, J3.29, J3.30, J3.34, J3.35, J3.38, J3.42, J3.45, J4.1, J5.2, J6.2, R1.1, R2.1, R3.1, SW1.1 (A), SW2.3 (C), TP8.1
unnamed: D1.1 (K), R1.2
unnamed: D2.1 (K), R2.2
unnamed: D3.1 (K), R3.2
unnamed: J3.4, R4.2
unnamed: J3.12, R5.2
unnamed: J3.32, R7.2

Notes on the sheet:
Connection to Gimletlet
RoT reset
RoT SWD
SPI (hackable to SWD)
UART (FTDI)
Debug LEDs
LPC55 Carrier
Boot mode
1-2 Passive Boot 2-3 ISP Boot
Missing CTX/RTX because they're not broken out from the carrier, and 3V3 because this board is powered from the Gimletlet
LPC55 mounting holes
Aux GPIOs
Newt of Trust

Board: 4 copper layers, 55.0 x 79.0 mm, 39 parts (0 on the bottom side), 31 nets.

## KiCad design lpc55_carrier.kicad_pcb

Parts:
C101, C113: 4.7uF 3.3VDCbias; C_0805_2012Metric; MPN C0805C475K4PACTU
C102, C104, C106, C108, C115, C118: 0.1uF 3.3VDCbias; C_0603_1608Metric; MPN C0603C104M4RACTU
C103, C105, C107, C109, C116, C125: 10000pF 3.3VDCbias; C_0603_1608Metric; MPN C0603C103K4RACTU
C110: 47pF 1.2VDCbias; C_0603_1608Metric; MPN C0603C470J4GAC7867
C111: 0.1uF 1.2VDCbias; C_0603_1608Metric; MPN C0603C104M4RACTU
C112: 2.2uF 1.2VDCbias; C_0805_2012Metric; MPN C0805C225K4RACTU
C114, C119: 47pF 3.3VDCbias; C_0603_1608Metric; MPN C0603C470J4GAC7867
C117: 22uF 3.3VDCbias; C_1210_3225Metric; MPN C1210C226K4PACTU
C120: 22uF 1.2VDCbias; C_1210_3225Metric; MPN C1210C226K4PACTU
C121, C122: 33pF 1.2VAC; C_0603_1608Metric; MPN C0603C300J5GACTU
C123, C124: 22pF 3.3VAC; C_0603_1608Metric; MPN C0603C220J1GACTU
D103: 1.25Vf 150mA; D_SOD-323; MPN 1N4148WS-G RVG
FB101, FB102: 600R @ 100MHz 10mA; L_0603_1608Metric; MPN BLM18KG601SN1D
H101, H102: M3; MountingHole_3.2mm_M3
J101: Conn_2Rows-51Pins; Hirose_DF9-51S-1V(69)_2Rows_51Pin-2MP_P1.0mm_Vertical; MPN DF9-51S-1V(69)
JP101, JP102, JP103, JP104: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
L101: 4.7uH 400mA 290mR; L_0805_2012Metric; MPN MLZ2012M4R7HT000
R101, R104, R108, R109, R110: 22R; R_0603_1608Metric; MPN CR0603-JW-220ELF
R103: 100kR; R_0603_1608Metric; MPN CR0603-JW-104ELF
TP101: GND; TestPoint_Pad_2.0x2.0mm
TP102: VDD; TestPoint_Pad_D2.0mm
TP103: XTAL_RTC; TestPoint_2Pads_Pitch8mm_D2.0mm
TP104: VDDA; TestPoint_Pad_D2.0mm
TP105: VDD_PMU; TestPoint_Pad_D2.0mm
TP106: XTAL_32M; TestPoint_2Pads_Pitch8mm_D2.0mm
TP107: ~RESET; TestPoint_Pad_D2.0mm
TP108: ISP0; TestPoint_Pad_D2.0mm
TP109: SWO; TestPoint_Pad_D2.0mm
U101: LPC55S28JBD64; HTQFP-64-1EP_10x10mm_P0.5mm_EP3.6x3.6mm; MPN LPC55S28JBD64K
Y101: 16MHz 18pF; Crystal_SMD_5032-4Pin_5.0x3.2mm; MPN H130B-16.000-18-3030-EXT-TR
Y102: 32.768kHz 12.5pF; Crystal_SMD_3215-2Pin_3.2x1.5mm; MPN FC-135 32.7680KA-A5

Connections:
+3V3: FB101.2, FB102.2, J101.44, J101.46, J101.47, J101.48, J101.49, J101.50, J101.51
/FB: C110.1, C111.1, C112.1, C120.1, L101.2, TP105.1, U101.28 (VDD_PMU), U101.29 (FB)
/FC0_RXD: J101.36, U101.59 (PIO0_29)
/FC0_TXD: J101.40, U101.60 (PIO0_30)
/FC3_CTS_SDAX_SSEL0: J101.32, U101.48 (PIO0_20)
/FC3_RTS_SCLX_SSEL1: J101.28, U101.49 (PIO0_21)
/FC3_RXD_DSA_MOSI: J101.12, U101.53 (PIO0_3/TCK)
/FC3_SCK: J101.4, U101.57 (PIO0_6/TDO)
/FC3_TXD_SCL_MISO: J101.16, U101.52 (PIO0_2/TRST)
/HS_SPI_MISO: J101.7, R101.1
/HS_SPI_MOSI: J101.15, U101.40 (PIO0_26)
/HS_SPI_SCK: J101.11, U101.41 (PIO1_2)
/ISP0: J101.3, TP108.1, U101.56 (PIO0_5/TDI)
/LX: L101.1, U101.31 (LX)
/OSC_IN: C121.1, JP101.1 (A), Y101.1
/OSC_OUT: C122.1, JP102.1 (A), Y101.3
/OSC_RTC_IN: C123.1, JP103.1 (A), Y102.1
/OSC_RTC_OUT: C124.1, JP104.1 (A), Y102.2
/PIO0_4: J101.8, U101.55 (PIO0_4/TMS)
/PIO0_10: R110.1, U101.13 (PIO0_10/ADC0_1)
/PIO0_11: R108.1, U101.6 (PIO0_11/ADC0_9)
/PIO0_12: R109.1, U101.5 (PIO0_12/ADC0_10)
/PIO0_18: J101.23, U101.38 (PIO0_18/ACMP0_C)
/PIO0_22: J101.24, U101.50 (PIO0_22)
/PIO0_25: J101.20, U101.51 (PIO0_25)
/PIO1_1: J101.19, U101.39 (PIO1_1/WAKEUP)
/PIO1_3: R101.2, U101.42 (PIO1_3)
/SCT0_OUT2: J101.31, U101.14 (PIO0_15/ADC0_2)
/SCT0_OUT3: J101.33, U101.15 (PIO0_31/ADC0_3)
/SWD_CLK: J101.39, R108.2
/SWD_IO: J101.41, R109.2
/SWD_TRACESWO: J101.37, R110.2, TP109.1
/VDD: C101.1, C102.1, C103.1, C104.1, C105.1, C106.1, C107.1, C108.1, C109.1, D103.1 (K), FB101.1, R103.1, TP102.1, U101.8 (VDD), U101.16 (VDD), U101.43 (VDD), U101.54 (VDD)
/VDDA: C113.1, C114.1, C115.1, C116.1, C117.1, C118.1, C119.1, FB102.1, TP104.1, U101.9 (VDDA), U101.10 (VREFP), U101.25 (USB1_VBUS), U101.27 (USB1_3V3), U101.32 (VBAT_DCDC), U101.33 (VBAT_PMU), U101.61 (USB0_3V3)
/XTAL32K_N: JP104.2 (C), U101.35 (XTAL32K_N)
/XTAL32K_P: JP103.2 (C), TP103.1, U101.34 (XTAL32K_P)
/XTAL32M_N: JP102.2 (C), U101.19 (XTAL32M_N)
/XTAL32M_P: JP101.2 (C), TP106.1, U101.20 (XTAL32M_P)
/~RESET: C125.1, D103.2 (A), R103.2, R104.1, TP107.1, U101.21 (~RESET)
/~SP_RESET: J101.27, U101.37 (PIO0_9/ACMP0_B)
/~SWD_RESET: J101.43, R104.2
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C119.2, C120.2, C121.2, C122.2, C123.2, C124.2, C125.2, J101.1, J101.2, J101.5, J101.6, J101.9, J101.10, J101.13, J101.14, J101.17, J101.18, J101.21, J101.22, J101.25, J101.26, J101.29, J101.30, J101.34, J101.35, J101.38, J101.42, J101.45, JP101.3 (B), JP103.3 (B), TP101.1, TP103.2, TP106.2, U101.11 (VSSA), U101.22 (USB1_VSS), U101.26 (USB1_VSS), U101.30 (VSS_DCDC), U101.64 (USB0_VSS), U101.65 (VSS)

Notes on the sheet:
Desired
Gemini Bringup Baseboard Connector
- PD PU PD PU
~{HS_SPI_SSEL1} and ~{HS_SPI_IRQ} must have internal pull-ups enabled
Crystals
PD PU -
Test Points
Power Filtering and Decoupling
Mounting
Pull Up/Down
Pull up/down
In/Out/ Hi-Z
C_L = 12.5pF C_pad = 3pF C_x1 = C _x2 = 2C_L - C_pad = 22pF
SWD_CLK SWD_IO SWD_TRACESWO
Debug, Reset
I I Z
Default PIO0_2 PIO0_5 PIO0_11 PIO0_12
Default to Passive Boot. Pull LOW for ISP boot.
Place 4.7uF near ferrite bead. Others near LPC55 VDD pins.
POR Pin Mode
C_L = 18pF C_pad = 3pF C_x1 = C _x2 = 2C_L - C_pad = 33pF
Pin
Z I I I I
PD PU PU
1 - 2 Xtal 2 - 3 No Xtal
ISP0
Input/Output/Hi-Z
SP->RoT SPI
Place 4.7uF near ferrite bead Place 47pF and 0.1uF near LPC55 VDDA Place 10nF near LPC55 VREFP Place 22uF, 100nF, and 47pF near LPC55 VBAT_DCDC and VBAT_PMU
I I O
POR

Board: 4 copper layers, 51.4 x 37.1 mm, 54 parts (9 on the bottom side), 42 nets.

## Commit log

2023-02-28 Initial refactor out of gemni repo
